# Keil uVision project HT32.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.23
  cpu: IROM(0x00000000,0x1FE00) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT32 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\HT32_text;.\CMSIS;.\Config;.\FWlib\inc;.\User;.\Bsp;.\Bsp\HT32_Board;.\Bsp\HT32_USBD_Library\inc;.\Bsp\common
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ./User/: main.c ht32f5xxxx_01_it.c
  group CMSIS
    ./CMSIS/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./Config/: startup_ht32f5xxxx_01.s ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group FWlib
    ./FWlib/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group Bsp
    ./Bsp/: led.c systick.c usart1.c sht3x_iic.c sgp30_iic.c bh1750_iic.c bmp180_iic.c oled_spi.c nrf24_spi.c esp8266.c
